# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\usart1;..\HARDWARE\timer2;..\HARDWARE\MOTOR;..\HARDWARE\USART3;..\HARDWARE\Main_Init;..\APP\OPS;..\APP\CanTask;..\HARDWARE\fast_math;..\HARDWARE\ENC;..\HARDWARE\MOVE_BASIC;..\HARDWARE\CAN1;..\HARDWARE\PID;..\HARDWARE\can2;..\HARDWARE\DBUS;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../HARDWARE/Main_Init/: Main_Init.c
    ../APP/OPS/: OPS.C
  group HARDWARE
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/timer2/: timer2.c
    ../HARDWARE/fast_math/: fast_math.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/ENC/: enc.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/MOVE_BASIC/: move_basic.c
    ../HARDWARE/CAN1/: can.c
    ../HARDWARE/can2/: can2.c
    ../HARDWARE/DBUS/: dbus.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c
  group README
    ../: readme.txt
